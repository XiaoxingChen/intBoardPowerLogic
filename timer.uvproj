# Keil uVision project timer.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C55 Atmel
  cpu: IRAM(0 - 0xFF) IROM(0 - 0x4FFF) CLOCK(24000000)
  output: timer +hex
  c flags: Optimize=9
  group Source Group 1
    ./: GPIO.c main.c timer.c power_manager.c key_monitor.c
